require neofetch.inc
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=d300b86297c170b6498705fbb6794e3f"
SRC_URI[md5sum] = "37ba9026fdd353f66d822fdce16420a8"
